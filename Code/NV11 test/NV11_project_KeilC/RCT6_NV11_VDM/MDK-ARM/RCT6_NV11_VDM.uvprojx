# Keil uVision project RCT6_NV11_VDM.uvprojx, settings and files
target RCT6_NV11_VDM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RCT6_NV11_VDM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Inc/app_debug;../Core/Inc/lwrb_h;../Core/Inc/nv11;../Core/Inc/ssp_h;../Core/Inc/vdm;..\Core\Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/app_debug/: app_debug.c
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Driver
    ../Core/Src/lwrb_c/: lwrb.c
    ../Core/Src/nv11/: nv11.c
    ../Core/Src/ssp_c/: Encryption.c ITLSSPProc.c Random.c serialfunc.c ssp_helpers.c SSPComs.c
    ../Core/Src/vdm/: vdm_device_config.c
    ../Core/Driver/: glcd.c glcd_font.c glcd.h glcd_font.h platform.h vnfont.c
software components: CMSIS:CORE 5.3.0
